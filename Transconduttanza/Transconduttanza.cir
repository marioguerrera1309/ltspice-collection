ESERCIZIO1
*
G1 0 2 1 0 1m
V1 1 0 AC 1
Rin 1 0 1k
R1 2 0 100k
C1 2 0 160p
.AC DEC 100 100 10meg
