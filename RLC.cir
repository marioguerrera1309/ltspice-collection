esempio 2
*
Vin 1 0 0 AC 1
L1 2 3 0.125
C1 3 0 1u
R1 1 2 20
.AC dec 100 1 10k
